# Keil uVision project Real_Time_ENV_info_monitor.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC-STC89
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: Real_Time_ENV_info_monitor +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./_main/: main.c
    ./lcd1602/: lcd1602.c
    ./uart/: uart.c
    ./wire1/: wire1.c
